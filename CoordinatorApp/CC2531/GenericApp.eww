<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CoordinatorApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CoordinatorApp</project>
        <configuration>Coordinator</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>Coordinator-SBL</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>EndDevice</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>EndDevice-SBL</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>Router</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>Router-SBL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


