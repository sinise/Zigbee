<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CoordinatorApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CoordinatorApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>CoordinatorEB-SBL</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>EndDeviceEB-SBL</configuration>
      </member>
      <member>
        <project>CoordinatorApp</project>
        <configuration>RouterEB-SBL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


